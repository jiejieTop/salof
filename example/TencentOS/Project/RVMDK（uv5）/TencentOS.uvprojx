# Keil uVision project TencentOS.uvprojx, settings and files
target salof (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: task +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\TencentOS\arch\arm\arm-v7m\common\include;..\..\TencentOS\arch\arm\arm-v7m\cortex-m3\armcc;..\..\TencentOS\kernel\core\include;..\..\TencentOS\kernel\pm\include;..\..\TencentOS\TOS-CONFIG;..\..\..\..\..\salof;..\..\salof_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart.c
  group tos/kernel
    ../../TencentOS/kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../../TencentOS/kernel/pm/: tos_pm.c tos_tickless.c
  group tos/arch
    ../../TencentOS/arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
    ../../TencentOS/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group tos/config
    ../../TencentOS/TOS-CONFIG/: tos_config.h
  group salof
    ../../../../arch/tencentos-tiny/: arch.c
    ../../../../: fifo.c format.c salof.c
